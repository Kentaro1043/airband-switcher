options:
  parameters:
    author: Kentaro1043
    generate_options: no_gui
    id: airband_demodulator
    output_language: python
    title: Airband Radio Demodulator
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 129.0e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 128.8e6
  states: {}
- name: output_path
  id: variable
  parameters:
    value: '"/tmp/gnuradio_audio.pcm"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.56e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: 5e3
    audio_stop: 5.5e3
    chan_rate: samp_rate / 80
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq - freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: output_path
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    decim: '80'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: center_freq
    gain0: '40'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_am_demod_cf_0, '0']
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0_0, '0', analog_agc_xx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
