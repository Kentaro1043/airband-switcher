options:
  parameters:
    author: Kentaro1043
    generate_options: no_gui
    id: airband_demodulator
    output_language: python
    title: Airband Radio Demodulator
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 128.8e6
  states: {}
- name: output_path
  id: variable
  parameters:
    value: '"/tmp/gnuradio_audio.pcm"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: output_path
    type: short
    unbuffered: 'True'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '32767.0'
    type: float
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    corr0: '25'
    freq0: freq
    gain0: '40'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccc
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_short_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_short_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
